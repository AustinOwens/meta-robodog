FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"
XSCTH_BUILD_DEBUG="1"
